# Keil uVision project Master.uvproj, settings and files
target Master (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: Master
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM
  c misc: --C99
  c include: ../../lib/_tm4c;../../lib/common/inc;../../lib/LCD/ST7735/inc;../../lib/LiDAR/VL53L0X/core/inc;../../lib/LiDAR/VL53L0X/platform/inc;../../lib/LiDAR/VL53L0X/VL53L0X/inc;..\..\lib\IR;..\..\lib\OS;..\VL53L0X_Distance_Measure_1_ST7735
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group src
    ./: master_main.c master_ssi.c
    ../../lib/common/src/: PLL.c
    ../../lib/_tm4c/: startup.s
    ../../lib/LCD/ST7735/src/: ST7735.c
  group os
    ../../lib/OS/: Interpreter.c OS.c UART2.c osasm.s
