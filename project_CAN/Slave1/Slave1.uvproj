# Keil uVision project Slave1.uvproj, settings and files
target Slave1 (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: Slave1
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --c99
  c include: ..;..\..\..;../inc/;../driverlib/;../others/
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s main.c Timer3.c can.c can0.c interrupt.c
  group others
    ../others/: Interpreter.c OS.c ST7735.c UART2.c PLL.c osasm.s
