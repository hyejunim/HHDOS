# Keil uVision project Server.uvproj, settings and files
target Server (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: Server
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --c99
  c include: src;../lib/_tm4c;../lib/common/inc;../lib/CAN;../lib/LCD;../lib/OS;../lib/FileSystem
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./src/: main.c Server_Thread.c
    ../lib/_tm4c/: startup.s
    ../lib/LCD/: ST7735.c
    ../lib/common/src/: PLL.c
  group OS
    ../lib/OS/: Interpreter.c OS.c osasm.s TCB.h
  group CAN
    ../lib/OS/: UART2.c
    ./src/: can0.c
    ../lib/CAN/: can.c Timer3.c interrupt.c
  group FileSystem
    ../lib/FileSystem/: eDisk.c eFile.c
